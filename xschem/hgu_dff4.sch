v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Stefan Schippers"}
C {devices/ipin.sym} 240 -260 0 0 {name=p36 lab=CLK}
C {devices/ipin.sym} 240 -230 0 0 {name=p40 lab=VDD}
C {devices/ipin.sym} 240 -200 0 0 {name=p41 lab=VSS}
C {devices/ipin.sym} 240 -160 0 0 {name=p42 lab=SET}
C {devices/ipin.sym} 240 -130 0 0 {name=p43 lab=RESET}
C {sky130_stdcells/dfbbp_1.sym} 610 -310 0 0 {name=x27 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/ipin.sym} 520 -320 0 0 {name=p31 lab=D}
C {devices/lab_pin.sym} 520 -340 0 0 {name=p47 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 440 -280 0 0 {name=p49 sig_type=std_logic lab=SET}
C {sky130_stdcells/inv_1.sym} 480 -280 0 0 {name=x4 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/opin.sym} 700 -320 0 0 {name=p50 lab=Qb}
C {devices/opin.sym} 700 -340 0 0 {name=p51 lab=Q}
C {devices/lab_pin.sym} 440 -300 0 0 {name=p55 sig_type=std_logic lab=RESET}
C {sky130_stdcells/inv_1.sym} 480 -300 0 0 {name=x5 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
