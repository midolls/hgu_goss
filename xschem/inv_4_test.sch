v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/hgu_goss/hgu/xschem/hgu_inverter.sym} -10 10 0 0 {name=x1}
C {/foss/designs/hgu_goss/hgu/xschem/hgu_inverter.sym} 140 10 0 0 {name=x2}
C {/foss/designs/hgu_goss/hgu/xschem/hgu_inverter.sym} 280 10 0 0 {name=x3}
C {/foss/designs/hgu_goss/hgu/xschem/hgu_inverter.sym} -160 10 0 0 {name=x4}
