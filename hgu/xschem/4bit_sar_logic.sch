v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 390 -720 420 -720 {
lab=#net1}
N 420 -740 420 -720 {
lab=#net1}
N 420 -740 500 -740 {
lab=#net1}
N 800 -720 880 -720 {
lab=#net2}
N 2510 -740 2510 -720 {
lab=#net3}
N 2510 -740 2610 -740 {
lab=#net3}
N 2910 -720 2930 -720 {
lab=#net4}
N 2930 -740 2930 -720 {
lab=#net4}
N 2930 -740 3010 -740 {
lab=#net4}
N 3310 -720 3330 -720 {
lab=#net5}
N 3330 -740 3330 -720 {
lab=#net5}
N 3330 -740 3410 -740 {
lab=#net5}
N 3710 -720 3730 -720 {
lab=check[0]}
N 3730 -740 3730 -720 {
lab=check[0]}
N 3730 -740 3800 -740 {
lab=check[0]}
N 4100 -720 4230 -720 {
lab=EOC}
N 4340 -400 4340 -380 {
lab=GND}
N 2510 -720 2510 -320 {
lab=#net3}
N 2510 -320 2610 -320 {
lab=#net3}
N 2930 -720 2930 -320 {
lab=#net4}
N 2930 -320 3030 -320 {
lab=#net4}
N 3330 -720 3330 -320 {
lab=#net5}
N 3330 -320 3410 -320 {
lab=#net5}
N 3730 -720 3730 -320 {
lab=check[0]}
N 3730 -320 3800 -320 {
lab=check[0]}
N 4640 -380 4660 -380 {
lab=#net6}
N 4660 -560 4660 -380 {
lab=#net6}
N 3760 -560 4660 -560 {
lab=#net6}
N 3760 -560 3760 -380 {
lab=#net6}
N 3760 -380 3800 -380 {
lab=#net6}
N 2910 -380 2910 -140 {
lab=D[3]}
N 3310 -380 3310 -140 {
lab=D[2]}
N 3710 -380 3710 -140 {
lab=D[1]}
N 4100 -380 4100 -140 {
lab=D[0]}
N 3340 -380 3410 -380 {
lab=D[0]}
N 3340 -380 3340 -260 {
lab=D[0]}
N 3340 -260 4100 -260 {
lab=D[0]}
N 2940 -380 3010 -380 {
lab=D[1]}
N 2940 -380 2940 -230 {
lab=D[1]}
N 2940 -230 3710 -230 {
lab=D[1]}
N 2540 -380 2610 -380 {
lab=D[2]}
N 2540 -380 2540 -250 {
lab=D[2]}
N 2540 -250 3310 -250 {
lab=D[2]}
N 880 -740 880 -720 {
lab=#net2}
N 880 -740 980 -740 {
lab=#net2}
N 1280 -720 1300 -720 {
lab=#net7}
N 1300 -740 1300 -720 {
lab=#net7}
N 1300 -740 1380 -740 {
lab=#net7}
N 1680 -720 1700 -720 {
lab=#net8}
N 1700 -740 1700 -720 {
lab=#net8}
N 1700 -740 1780 -740 {
lab=#net8}
N 2080 -720 2100 -720 {
lab=#net9}
N 2100 -740 2100 -720 {
lab=#net9}
N 2100 -740 2170 -740 {
lab=#net9}
N 880 -720 880 -320 {
lab=#net2}
N 880 -320 980 -320 {
lab=#net2}
N 1300 -720 1300 -320 {
lab=#net7}
N 1300 -320 1400 -320 {
lab=#net7}
N 1700 -720 1700 -320 {
lab=#net8}
N 1700 -320 1780 -320 {
lab=#net8}
N 2100 -720 2100 -320 {
lab=#net9}
N 2100 -320 2170 -320 {
lab=#net9}
N 1280 -380 1280 -140 {
lab=D[7]}
N 1680 -380 1680 -140 {
lab=D[6]}
N 2080 -380 2080 -140 {
lab=D[5]}
N 2470 -380 2470 -140 {
lab=D[4]}
N 1710 -380 1780 -380 {
lab=D[4]}
N 1710 -380 1710 -260 {
lab=D[4]}
N 1710 -260 2470 -260 {
lab=D[4]}
N 1310 -380 1380 -380 {
lab=D[5]}
N 1310 -380 1310 -230 {
lab=D[5]}
N 1310 -230 2080 -230 {
lab=D[5]}
N 910 -380 980 -380 {
lab=D[6]}
N 910 -380 910 -250 {
lab=D[6]}
N 910 -250 1680 -250 {
lab=D[6]}
N 2470 -720 2510 -720 {
lab=#net3}
N 2110 -380 2170 -380 {
lab=D[3]}
N 2110 -380 2110 -230 {
lab=D[3]}
N 2110 -230 2910 -230 {
lab=D[3]}
N 2550 -980 2550 -740 {
lab=D[3]}
N 2950 -980 2950 -740 {
lab=D[2]}
N 3350 -980 3350 -740 {
lab=D[1]}
N 3740 -980 3740 -740 {
lab=D[0]}
N 920 -980 920 -740 {
lab=D[7]}
N 1320 -980 1320 -740 {
lab=D[6]}
N 1720 -980 1720 -740 {
lab=D[5]}
N 2110 -980 2110 -740 {
lab=D[4]}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="sample_clk_gen"}
C {dff_4.sym} 2760 -350 0 0 {name=x1}
C {dff_4.sym} 3160 -350 0 0 {name=x2}
C {dff_4.sym} 3560 -350 0 0 {name=x3}
C {dff_4.sym} 3950 -350 0 0 {name=x4}
C {dff_4.sym} 4490 -350 0 0 {name=x5}
C {dff_4.sym} 2760 -690 0 0 {name=x6}
C {dff_4.sym} 3160 -690 0 0 {name=x7}
C {dff_4.sym} 3560 -690 0 0 {name=x8}
C {dff_4.sym} 3950 -690 0 0 {name=x9}
C {dff_4.sym} 240 -690 0 0 {name=x10}
C {dff_4.sym} 650 -690 0 0 {name=x11}
C {devices/ipin.sym} 130 -340 0 0 {name=p4 lab=clk_sar}
C {devices/ipin.sym} 130 -210 0 0 {name=p1 lab=VDD}
C {devices/ipin.sym} 130 -180 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 130 -310 0 0 {name=p3 lab=comparator_out}
C {devices/ipin.sym} 130 -280 0 0 {name=p5 lab=reset}
C {devices/opin.sym} 220 -340 0 0 {name=p6 lab=EOC}
C {devices/opin.sym} 220 -310 0 0 {name=p7 lab=D[0:7]}
C {devices/lab_pin.sym} 90 -700 0 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 90 -680 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 500 -700 0 0 {name=p10 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 500 -680 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2610 -700 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2610 -680 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2610 -360 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2610 -340 0 0 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3010 -360 0 0 {name=p16 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3010 -340 0 0 {name=p17 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3010 -700 0 0 {name=p18 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3010 -680 0 0 {name=p19 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3410 -700 0 0 {name=p20 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3410 -680 0 0 {name=p21 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3410 -360 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3410 -340 0 0 {name=p23 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3800 -360 0 0 {name=p24 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3800 -340 0 0 {name=p25 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4340 -360 0 0 {name=p26 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 4340 -340 0 0 {name=p27 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3800 -700 0 0 {name=p28 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3800 -680 0 0 {name=p29 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 90 -740 0 0 {name=p30 sig_type=std_logic lab=EOC}
C {devices/lab_pin.sym} 90 -720 0 0 {name=p31 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 500 -720 0 0 {name=p32 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 2610 -720 0 0 {name=p33 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 3010 -720 0 0 {name=p34 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 3410 -720 0 0 {name=p35 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 3800 -720 0 0 {name=p36 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 90 -640 0 0 {name=p37 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 500 -660 0 0 {name=p38 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2610 -660 0 0 {name=p39 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3010 -660 0 0 {name=p40 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3410 -660 0 0 {name=p41 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3800 -660 0 0 {name=p42 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 90 -660 0 0 {name=p43 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 500 -640 0 0 {name=p44 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 2610 -640 0 0 {name=p45 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 3010 -640 0 0 {name=p46 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 3410 -640 0 0 {name=p47 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 3800 -640 0 0 {name=p48 sig_type=std_logic lab=reset}
C {devices/gnd.sym} 390 -740 2 0 {name=l2 lab=GND}
C {devices/gnd.sym} 800 -740 2 0 {name=l3 lab=GND}
C {devices/gnd.sym} 2910 -740 2 0 {name=l4 lab=GND}
C {devices/gnd.sym} 3310 -740 2 0 {name=l5 lab=GND}
C {devices/gnd.sym} 3710 -740 2 0 {name=l6 lab=GND}
C {devices/gnd.sym} 4100 -740 2 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 4230 -720 2 0 {name=p49 sig_type=std_logic lab=EOC}
C {devices/gnd.sym} 4340 -400 2 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 4340 -320 0 0 {name=p50 sig_type=std_logic lab=EOC}
C {devices/lab_pin.sym} 4340 -300 0 0 {name=p51 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 3800 -300 0 0 {name=p52 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 3410 -300 0 0 {name=p53 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 3010 -300 0 0 {name=p54 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 2610 -300 0 0 {name=p55 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 2610 -400 1 0 {name=p56 sig_type=std_logic lab=comparator_out}
C {devices/lab_pin.sym} 3010 -400 1 0 {name=p57 sig_type=std_logic lab=comparator_out}
C {devices/lab_pin.sym} 3410 -400 1 0 {name=p58 sig_type=std_logic lab=comparator_out}
C {devices/lab_pin.sym} 3800 -400 1 0 {name=p59 sig_type=std_logic lab=comparator_out}
C {devices/gnd.sym} 4640 -400 2 0 {name=l9 lab=GND}
C {devices/gnd.sym} 4100 -400 2 0 {name=l10 lab=GND}
C {devices/gnd.sym} 3710 -400 2 0 {name=l11 lab=GND}
C {devices/gnd.sym} 3310 -400 2 0 {name=l12 lab=GND}
C {devices/gnd.sym} 2910 -400 2 0 {name=l13 lab=GND}
C {devices/lab_pin.sym} 2910 -140 0 0 {name=p60 sig_type=std_logic lab=D[3]}
C {devices/lab_pin.sym} 3310 -140 0 0 {name=p61 sig_type=std_logic lab=D[2]}
C {devices/lab_pin.sym} 3710 -140 0 0 {name=p62 sig_type=std_logic lab=D[1]}
C {devices/lab_pin.sym} 4100 -140 0 0 {name=p63 sig_type=std_logic lab=D[0]}
C {dff_4.sym} 1130 -350 0 0 {name=x12}
C {dff_4.sym} 1530 -350 0 0 {name=x13}
C {dff_4.sym} 1930 -350 0 0 {name=x14}
C {dff_4.sym} 2320 -350 0 0 {name=x15}
C {dff_4.sym} 1130 -690 0 0 {name=x16}
C {dff_4.sym} 1530 -690 0 0 {name=x17}
C {dff_4.sym} 1930 -690 0 0 {name=x18}
C {dff_4.sym} 2320 -690 0 0 {name=x19}
C {devices/lab_pin.sym} 980 -700 0 0 {name=p67 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 980 -680 0 0 {name=p68 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 980 -360 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 980 -340 0 0 {name=p70 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1380 -360 0 0 {name=p71 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1380 -340 0 0 {name=p72 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1380 -700 0 0 {name=p73 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1380 -680 0 0 {name=p74 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1780 -700 0 0 {name=p75 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1780 -680 0 0 {name=p76 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1780 -360 0 0 {name=p77 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1780 -340 0 0 {name=p78 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2170 -360 0 0 {name=p79 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2170 -340 0 0 {name=p80 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2170 -700 0 0 {name=p81 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2170 -680 0 0 {name=p82 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 980 -720 0 0 {name=p83 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 1380 -720 0 0 {name=p84 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 1780 -720 0 0 {name=p85 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 2170 -720 0 0 {name=p86 sig_type=std_logic lab=clk_sar}
C {devices/lab_pin.sym} 980 -660 0 0 {name=p87 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1380 -660 0 0 {name=p88 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1780 -660 0 0 {name=p89 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2170 -660 0 0 {name=p90 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 980 -640 0 0 {name=p91 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 1380 -640 0 0 {name=p92 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 1780 -640 0 0 {name=p93 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 2170 -640 0 0 {name=p94 sig_type=std_logic lab=reset}
C {devices/gnd.sym} 1280 -740 2 0 {name=l14 lab=GND}
C {devices/gnd.sym} 1680 -740 2 0 {name=l15 lab=GND}
C {devices/gnd.sym} 2080 -740 2 0 {name=l16 lab=GND}
C {devices/gnd.sym} 2470 -740 2 0 {name=l17 lab=GND}
C {devices/lab_pin.sym} 2170 -300 0 0 {name=p95 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 1780 -300 0 0 {name=p96 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 1380 -300 0 0 {name=p97 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 980 -300 0 0 {name=p98 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 980 -400 1 0 {name=p99 sig_type=std_logic lab=comparator_out}
C {devices/lab_pin.sym} 1380 -400 1 0 {name=p100 sig_type=std_logic lab=comparator_out}
C {devices/lab_pin.sym} 1780 -400 1 0 {name=p101 sig_type=std_logic lab=comparator_out}
C {devices/lab_pin.sym} 2170 -400 1 0 {name=p102 sig_type=std_logic lab=comparator_out}
C {devices/gnd.sym} 2470 -400 2 0 {name=l18 lab=GND}
C {devices/gnd.sym} 2080 -400 2 0 {name=l19 lab=GND}
C {devices/gnd.sym} 1680 -400 2 0 {name=l20 lab=GND}
C {devices/gnd.sym} 1280 -400 2 0 {name=l21 lab=GND}
C {devices/lab_pin.sym} 1280 -140 0 0 {name=p103 sig_type=std_logic lab=D[7]}
C {devices/lab_pin.sym} 1680 -140 0 0 {name=p104 sig_type=std_logic lab=D[6]}
C {devices/lab_pin.sym} 2080 -140 0 0 {name=p105 sig_type=std_logic lab=D[5]}
C {devices/lab_pin.sym} 2470 -140 0 0 {name=p106 sig_type=std_logic lab=D[4]}
