** sch_path: hgu/xschem/hgu_delay.sch
**.subckt hgu_delay IN VDD VSS OUT SAMPLE_CODE1[0],SAMPLE_CODE1[1],SAMPLE_CODE1[2],SAMPLE_CODE1[3]
*+ SAMPLE_CODE2[0],SAMPLE_CODE2[1],SAMPLE_CODE2[2],SAMPLE_CODE2[3] SAMPLE_CODE3[0],SAMPLE_CODE3[1],SAMPLE_CODE3[2],SAMPLE_CODE3[3]
*+ SAMPLE_CODE0[0],SAMPLE_CODE0[1],SAMPLE_CODE0[2],SAMPLE_CODE0[3] sample_delay_offset
*.ipin IN
*.ipin VDD
*.ipin VSS
*.opin OUT
*.ipin SAMPLE_CODE1[0],SAMPLE_CODE1[1],SAMPLE_CODE1[2],SAMPLE_CODE1[3]
*.ipin SAMPLE_CODE2[0],SAMPLE_CODE2[1],SAMPLE_CODE2[2],SAMPLE_CODE2[3]
*.ipin SAMPLE_CODE3[0],SAMPLE_CODE3[1],SAMPLE_CODE3[2],SAMPLE_CODE3[3]
*.ipin SAMPLE_CODE0[0],SAMPLE_CODE0[1],SAMPLE_CODE0[2],SAMPLE_CODE0[3]
*.ipin sample_delay_offset
x4 VDD IN net1 VSS SAMPLE_CODE0[0] SAMPLE_CODE0[1] SAMPLE_CODE0[2] SAMPLE_CODE0[3]
+ sample_delay_offset hgu_delay_no_code
x1 VDD net1 net2 VSS SAMPLE_CODE1[0] SAMPLE_CODE1[1] SAMPLE_CODE1[2] SAMPLE_CODE1[3]
+ sample_delay_offset hgu_delay_no_code
x2 VDD net2 net3 VSS SAMPLE_CODE2[0] SAMPLE_CODE2[1] SAMPLE_CODE2[2] SAMPLE_CODE2[3]
+ sample_delay_offset hgu_delay_no_code
x3 VDD net3 OUT VSS SAMPLE_CODE3[0] SAMPLE_CODE3[1] SAMPLE_CODE3[2] SAMPLE_CODE3[3]
+ sample_delay_offset hgu_delay_no_code
**.ends
.end
