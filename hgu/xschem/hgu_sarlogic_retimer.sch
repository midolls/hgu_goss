v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/dfbbp_1.sym} 790 -260 0 0 {name=x1[0:7] VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/ipin.sym} 480 -240 0 0 {name=p31 lab=sar_logic[0:7]}
C {devices/opin.sym} 510 -170 0 0 {name=p57 lab=sar_retimer[0:7]}
C {devices/noconn.sym} 880 -270 0 1 {name=l8}
C {devices/ipin.sym} 480 -220 0 0 {name=p1 lab=eob}
C {devices/lab_pin.sym} 650 -420 2 1 {name=p8 sig_type=std_logic lab=eob}
C {devices/lab_pin.sym} 950 -440 2 0 {name=p2 sig_type=std_logic lab=eob_delay}
C {devices/ipin.sym} 480 -290 0 0 {name=p3 lab=VDD}
C {devices/ipin.sym} 480 -270 0 0 {name=p4 lab=VSS}
C {devices/lab_pin.sym} 650 -440 2 1 {name=p5 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 650 -400 2 1 {name=p6 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 480 -190 0 0 {name=p7 lab=delay_code[0:3]}
C {devices/ipin.sym} 480 -170 0 0 {name=p9 lab=delay_offset}
C {devices/lab_pin.sym} 650 -380 2 1 {name=p10 sig_type=std_logic lab=delay_code[0:3]}
C {devices/lab_pin.sym} 650 -360 2 1 {name=p11 sig_type=std_logic lab=delay_offset}
C {devices/lab_pin.sym} 700 -290 0 0 {name=p12 sig_type=std_logic lab=eob_delay}
C {/foss/designs/hgu_goss/hgu/xschem/hgu_delay_no_code.sym} 800 -410 0 0 {name=x2}
C {devices/lab_pin.sym} 700 -270 0 0 {name=p13 sig_type=std_logic lab=sar_logic[0:7]}
C {devices/lab_pin.sym} 880 -290 2 0 {name=p14 sig_type=std_logic lab=sar_retimer[0:7]}
C {devices/lab_pin.sym} 700 -250 2 1 {name=p15 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 700 -230 2 1 {name=p16 sig_type=std_logic lab=VDD}
