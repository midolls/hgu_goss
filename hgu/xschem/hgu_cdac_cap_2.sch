v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/hgu_goss/hgu/mag/../xschem/hgu_vpp_cap.sym} 40 40 0 0 {name=x1
model=hgu_cdac_unit}
C {/foss/designs/hgu_goss/hgu/mag/../xschem/hgu_vpp_cap.sym} 130 60 0 0 {name=x2
model=hgu_cdac_unit}
