** sch_path: hgu/xschem/hgu_sarlogic.sch
**.subckt hgu_sarlogic VDD VSS COMP_RESULT READY EXT_CLK sar_clk
*+ sar_result[0],sar_result[1],sar_result[2],sar_result[3],sar_result[4],sar_result[5],sar_result[6],sar_result[7] sample_clk sel_bit[0],sel_bit[1]
*+ sample_delay_cap_ctrl_code[0],sample_delay_cap_ctrl_code[1],sample_delay_cap_ctrl_code[2],sample_delay_cap_ctrl_code[3],sample_delay_cap_ctrl_code[4],sample_delay_cap_ctrl_code[5],sample_delay_cap_ctrl_code[6],sample_delay_cap_ctrl_code[7],sample_delay_cap_ctrl_code[8],sample_delay_cap_ctrl_code[9],sample_delay_cap_ctrl_code[10],sample_delay_cap_ctrl_code[11],sample_delay_cap_ctrl_code[12],sample_delay_cap_ctrl_code[13],sample_delay_cap_ctrl_code[14],sample_delay_cap_ctrl_code[15] sample_clk_b vdd_sw[1],vdd_sw[2],vdd_sw[3],vdd_sw[4],vdd_sw[5],vdd_sw[6],vdd_sw[7]
*+ vdd_sw_b[1],vdd_sw_b[2],vdd_sw_b[3],vdd_sw_b[4],vdd_sw_b[5],vdd_sw_b[6],vdd_sw_b[7] vss_sw[1],vss_sw[2],vss_sw[3],vss_sw[4],vss_sw[5],vss_sw[6],vss_sw[7]
*+ vss_sw_b[1],vss_sw_b[2],vss_sw_b[3],vss_sw_b[4],vss_sw_b[5],vss_sw_b[6],vss_sw_b[7]
*+ async_resetb_delay_cap_ctrl_code[0],async_resetb_delay_cap_ctrl_code[1],async_resetb_delay_cap_ctrl_code[2],async_resetb_delay_cap_ctrl_code[3]
*+ async_setb_delay_cap_ctrl_code[0],async_setb_delay_cap_ctrl_code[1],async_setb_delay_cap_ctrl_code[2],async_setb_delay_cap_ctrl_code[3]
*.ipin VDD
*.ipin VSS
*.ipin COMP_RESULT
*.ipin READY
*.ipin EXT_CLK
*.opin sar_clk
*.opin
*+ sar_result[0],sar_result[1],sar_result[2],sar_result[3],sar_result[4],sar_result[5],sar_result[6],sar_result[7]
*.opin sample_clk
*.ipin sel_bit[0],sel_bit[1]
*.ipin
*+ sample_delay_cap_ctrl_code[0],sample_delay_cap_ctrl_code[1],sample_delay_cap_ctrl_code[2],sample_delay_cap_ctrl_code[3],sample_delay_cap_ctrl_code[4],sample_delay_cap_ctrl_code[5],sample_delay_cap_ctrl_code[6],sample_delay_cap_ctrl_code[7],sample_delay_cap_ctrl_code[8],sample_delay_cap_ctrl_code[9],sample_delay_cap_ctrl_code[10],sample_delay_cap_ctrl_code[11],sample_delay_cap_ctrl_code[12],sample_delay_cap_ctrl_code[13],sample_delay_cap_ctrl_code[14],sample_delay_cap_ctrl_code[15]
*.opin sample_clk_b
*.opin vdd_sw[1],vdd_sw[2],vdd_sw[3],vdd_sw[4],vdd_sw[5],vdd_sw[6],vdd_sw[7]
*.opin vdd_sw_b[1],vdd_sw_b[2],vdd_sw_b[3],vdd_sw_b[4],vdd_sw_b[5],vdd_sw_b[6],vdd_sw_b[7]
*.opin vss_sw[1],vss_sw[2],vss_sw[3],vss_sw[4],vss_sw[5],vss_sw[6],vss_sw[7]
*.opin vss_sw_b[1],vss_sw_b[2],vss_sw_b[3],vss_sw_b[4],vss_sw_b[5],vss_sw_b[6],vss_sw_b[7]
*.ipin
*+ async_resetb_delay_cap_ctrl_code[0],async_resetb_delay_cap_ctrl_code[1],async_resetb_delay_cap_ctrl_code[2],async_resetb_delay_cap_ctrl_code[3]
*.ipin
*+ async_setb_delay_cap_ctrl_code[0],async_setb_delay_cap_ctrl_code[1],async_setb_delay_cap_ctrl_code[2],async_setb_delay_cap_ctrl_code[3]
x1 sar_clk VDD VSS sample_clk EOB READY async_resetb_delay_cap_ctrl_code[0]
+ async_resetb_delay_cap_ctrl_code[1] async_resetb_delay_cap_ctrl_code[2] async_resetb_delay_cap_ctrl_code[3]
+ async_setb_delay_cap_ctrl_code[0] async_setb_delay_cap_ctrl_code[1] async_setb_delay_cap_ctrl_code[2]
+ async_setb_delay_cap_ctrl_code[3] hgu_clk_async
x2 sample_clk_b VDD VSS EXT_CLK VSS VSS sample_clk sample_delay_cap_ctrl_code[0]
+ sample_delay_cap_ctrl_code[1] sample_delay_cap_ctrl_code[2] sample_delay_cap_ctrl_code[3] sample_delay_cap_ctrl_code[4]
+ sample_delay_cap_ctrl_code[5] sample_delay_cap_ctrl_code[6] sample_delay_cap_ctrl_code[7] sample_delay_cap_ctrl_code[8]
+ sample_delay_cap_ctrl_code[9] sample_delay_cap_ctrl_code[10] sample_delay_cap_ctrl_code[11] sample_delay_cap_ctrl_code[12]
+ sample_delay_cap_ctrl_code[13] sample_delay_cap_ctrl_code[14] sample_delay_cap_ctrl_code[15] hgu_clk_sample
x3 sel_bit[0] sel_bit[1] EOB sar_clk sar_result[0] sar_result[1] sar_result[2] sar_result[3]
+ sar_result[4] sar_result[5] sar_result[6] sar_result[7] COMP_RESULT check[0] check[1] check[2] check[3] check[4]
+ check[5] check[6] sample_clk_b VDD VSS hgu_sarlogic_8bit_logic csize=0.001
C1 sample_clk VSS 5f m=1
C2 sar_clk VSS 5f m=1
C3 EOB VSS 5f m=1
x4 VDD VSS vdd_sw[1] vdd_sw[2] vdd_sw[3] vdd_sw[4] vdd_sw[5] vdd_sw[6] vdd_sw[7] vdd_sw_b[1]
+ vdd_sw_b[2] vdd_sw_b[3] vdd_sw_b[4] vdd_sw_b[5] vdd_sw_b[6] vdd_sw_b[7] sar_result[1] sar_result[2]
+ sar_result[3] sar_result[4] sar_result[5] sar_result[6] sar_result[7] vss_sw[1] vss_sw[2] vss_sw[3] vss_sw[4]
+ vss_sw[5] vss_sw[6] vss_sw[7] check[0] check[1] check[2] check[3] check[4] check[5] check[6] vss_sw_b[1]
+ vss_sw_b[2] vss_sw_b[3] vss_sw_b[4] vss_sw_b[5] vss_sw_b[6] vss_sw_b[7] sar_clk sample_clk_b
+ hgu_sarlogic_sw_ctrl
**.ends

* expanding   symbol:  ../xschem/hgu_clk_async.sym # of pins=8
** sym_path: hgu/xschem/hgu_clk_async.sym
** sch_path: hgu/xschem/hgu_clk_async.sch
.subckt hgu_clk_async ASYNC_CLK_SAR VDD VSS sample_clk EOC READY async_resetb_delay_ctrl_code[0]
+ async_resetb_delay_ctrl_code[1] async_resetb_delay_ctrl_code[2] async_resetb_delay_ctrl_code[3] async_setb_delay_ctrl_code[0]
+ async_setb_delay_ctrl_code[1] async_setb_delay_ctrl_code[2] async_setb_delay_ctrl_code[3]
*.ipin VDD
*.opin ASYNC_CLK_SAR
*.ipin VSS
*.ipin sample_clk
*.ipin EOC
*.ipin READY
*.ipin
*+ async_resetb_delay_ctrl_code[0],async_resetb_delay_ctrl_code[1],async_resetb_delay_ctrl_code[2],async_resetb_delay_ctrl_code[3]
*.ipin
*+ async_setb_delay_ctrl_code[0],async_setb_delay_ctrl_code[1],async_setb_delay_ctrl_code[2],async_setb_delay_ctrl_code[3]
x3 net2 VSS sample_clk VGND VNB VPB VPWR net4 sky130_fd_sc_hd__mux2_1
x8 net4 VSS EOC VGND VNB VPB VPWR ASYNC_CLK_SAR sky130_fd_sc_hd__mux2_1
x27 sample_clk VDD net5 net6 VGND VNB VPB VPWR net2 net7 sky130_fd_sc_hd__dfbbp_1
x9 net1 VGND VNB VPB VPWR net6 sky130_fd_sc_hd__inv_1
x10 net3 VGND VNB VPB VPWR net5 sky130_fd_sc_hd__inv_1
* noconn #net7
C3 net2 VSS 5f m=1
C4 net4 VSS 5f m=1
x2 VDD READY net1 VSS async_setb_delay_ctrl_code[0] async_setb_delay_ctrl_code[1]
+ async_setb_delay_ctrl_code[2] async_setb_delay_ctrl_code[3] hgu_delay_no_code
x4 VDD ASYNC_CLK_SAR net3 VSS async_resetb_delay_ctrl_code[0] async_resetb_delay_ctrl_code[1]
+ async_resetb_delay_ctrl_code[2] async_resetb_delay_ctrl_code[3] hgu_delay_no_code
C1 net3 VSS 5f m=1
C2 net1 VSS 5f m=1
.ends


* expanding   symbol:  ../xschem/hgu_clk_sample.sym # of pins=11
** sym_path: hgu/xschem/hgu_clk_sample.sym
** sch_path: hgu/xschem/hgu_clk_sample.sch
.subckt hgu_clk_sample SAMPLE_CLK_b VDD VSS CLK RESET SET SAMPLE_CLK CAP_CTRL_CODE0[0]
+ CAP_CTRL_CODE0[1] CAP_CTRL_CODE0[2] CAP_CTRL_CODE0[3] CAP_CTRL_CODE1[0] CAP_CTRL_CODE1[1] CAP_CTRL_CODE1[2]
+ CAP_CTRL_CODE1[3] CAP_CTRL_CODE2[0] CAP_CTRL_CODE2[1] CAP_CTRL_CODE2[2] CAP_CTRL_CODE2[3] CAP_CTRL_CODE3[0]
+ CAP_CTRL_CODE3[1] CAP_CTRL_CODE3[2] CAP_CTRL_CODE3[3]
*.ipin VDD
*.ipin VSS
*.ipin SET
*.ipin RESET
*.ipin CLK
*.opin SAMPLE_CLK
*.opin SAMPLE_CLK_b
*.ipin CAP_CTRL_CODE1[0],CAP_CTRL_CODE1[1],CAP_CTRL_CODE1[2],CAP_CTRL_CODE1[3]
*.ipin CAP_CTRL_CODE2[0],CAP_CTRL_CODE2[1],CAP_CTRL_CODE2[2],CAP_CTRL_CODE2[3]
*.ipin CAP_CTRL_CODE3[0],CAP_CTRL_CODE3[1],CAP_CTRL_CODE3[2],CAP_CTRL_CODE3[3]
*.ipin CAP_CTRL_CODE0[0],CAP_CTRL_CODE0[1],CAP_CTRL_CODE0[2],CAP_CTRL_CODE0[3]
x1 net2 CLK RESET SET hgu_clk_div
x2 net8 net2 VDD VSS CAP_CTRL_CODE0[0] CAP_CTRL_CODE0[1] CAP_CTRL_CODE0[2] CAP_CTRL_CODE0[3]
+ CAP_CTRL_CODE1[0] CAP_CTRL_CODE1[1] CAP_CTRL_CODE1[2] CAP_CTRL_CODE1[3] CAP_CTRL_CODE2[0] CAP_CTRL_CODE2[1]
+ CAP_CTRL_CODE2[2] CAP_CTRL_CODE2[3] CAP_CTRL_CODE3[0] CAP_CTRL_CODE3[1] CAP_CTRL_CODE3[2] CAP_CTRL_CODE3[3] hgu_delay
+ DELAY_CAP=8f
x7 net8 VGND VNB VPB VPWR net1 sky130_fd_sc_hd__inv_1
C1 net1 VSS 5f m=1
C2 net2 VSS 5f m=1
C3 net8 VSS 5f m=1
x3 net2 net1 VGND VNB VPB VPWR net4 sky130_fd_sc_hd__nand2_1
XM7 net7 net3 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 net7 net3 VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1.26 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM9 net5 net4 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM10 net5 net4 VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1.4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM11 net6 net5 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM12 net6 net5 VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1.26 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM13 net4 VSS net3 VDD sky130_fd_pr__pfet_01v8 L=0.15 W=1.9 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM14 net4 VDD net3 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM15 SAMPLE_CLK net6 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W='0.42 * 3 ' nf=3 ad='int((nf+1)/2) * W / nf * 0.29'
+ as='int((nf+2)/2) * W / nf * 0.29' pd='2*int((nf+1)/2) * (W / nf + 0.29)' ps='2*int((nf+2)/2) * (W / nf + 0.29)'
+ nrd='0.29 / W ' nrs='0.29 / W ' sa=0 sb=0 sd=0 mult=1 m=1
XM16 SAMPLE_CLK net6 VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W='1.26 * 3 ' nf=3 ad='int((nf+1)/2) * W / nf * 0.29'
+ as='int((nf+2)/2) * W / nf * 0.29' pd='2*int((nf+1)/2) * (W / nf + 0.29)' ps='2*int((nf+2)/2) * (W / nf + 0.29)'
+ nrd='0.29 / W ' nrs='0.29 / W ' sa=0 sb=0 sd=0 mult=1 m=1
XM17 SAMPLE_CLK_b net7 VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W='1.26 * 3 ' nf=3 ad='int((nf+1)/2) * W / nf * 0.29'
+ as='int((nf+2)/2) * W / nf * 0.29' pd='2*int((nf+1)/2) * (W / nf + 0.29)' ps='2*int((nf+2)/2) * (W / nf + 0.29)'
+ nrd='0.29 / W ' nrs='0.29 / W ' sa=0 sb=0 sd=0 mult=1 m=1
XM18 SAMPLE_CLK_b net7 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W='0.42 * 3 ' nf=3 ad='int((nf+1)/2) * W / nf * 0.29'
+ as='int((nf+2)/2) * W / nf * 0.29' pd='2*int((nf+1)/2) * (W / nf + 0.29)' ps='2*int((nf+2)/2) * (W / nf + 0.29)'
+ nrd='0.29 / W ' nrs='0.29 / W ' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  ../xschem/hgu_sarlogic_8bit_logic.sym # of pins=9
** sym_path: hgu/xschem/hgu_sarlogic_8bit_logic.sym
** sch_path: hgu/xschem/hgu_sarlogic_8bit_logic.sch
.subckt hgu_sarlogic_8bit_logic sel_bit[0] sel_bit[1] EOB clk_sar D[0] D[1] D[2] D[3] D[4] D[5] D[6]
+ D[7] comparator_out check[0] check[1] check[2] check[3] check[4] check[5] check[6] reset VDD VSS
+  csize=csize
*.ipin clk_sar
*.ipin VDD
*.ipin VSS
*.ipin comparator_out
*.ipin reset
*.opin EOB
*.opin D[0],D[1],D[2],D[3],D[4],D[5],D[6],D[7]
*.opin check[0],check[1],check[2],check[3],check[4],check[5],check[6]
*.ipin sel_bit[0],sel_bit[1]
x20 clk_sar_buff EOB VDD resetb VSS VSS VDD VDD net1 net4 sky130_fd_sc_hd__dfbbp_1
x27 clk_sar_buff net1 resetb VDD VSS VSS VDD VDD check[6] net5 sky130_fd_sc_hd__dfbbp_1
x30 clk_sar_buff check[6] resetb VDD VSS VSS VDD VDD check[5] net6 sky130_fd_sc_hd__dfbbp_1
x33 clk_sar_buff check[5] resetb VDD VSS VSS VDD VDD check[4] net7 sky130_fd_sc_hd__dfbbp_1
x36 clk_sar_buff check[4] resetb VDD VSS VSS VDD VDD check[3] net8 sky130_fd_sc_hd__dfbbp_1
x39 clk_sar_buff check[3] resetb VDD VSS VSS VDD VDD check[2] net9 sky130_fd_sc_hd__dfbbp_1
x42 clk_sar_buff check[2] resetb VDD VSS VSS VDD VDD check[1] net10 sky130_fd_sc_hd__dfbbp_1
x45 clk_sar_buff check[1] resetb VDD VSS VSS VDD VDD check[0] net11 sky130_fd_sc_hd__dfbbp_1
x48 clk_sar_buff check[0] resetb VDD VSS VSS VDD VDD net3 net12 sky130_fd_sc_hd__dfbbp_1
x51 D[6] comparator_out_buff resetb net4 VSS VSS VDD VDD D[7] net13 sky130_fd_sc_hd__dfbbp_1
x54 D[5] comparator_out_buff resetb net5 VSS VSS VDD VDD D[6] net14 sky130_fd_sc_hd__dfbbp_1
x57 D[4] comparator_out_buff resetb net6 VSS VSS VDD VDD D[5] net15 sky130_fd_sc_hd__dfbbp_1
x60 D[3] comparator_out_buff resetb net7 VSS VSS VDD VDD D[4] net16 sky130_fd_sc_hd__dfbbp_1
x63 D[2] comparator_out_buff resetb net8 VSS VSS VDD VDD D[3] net17 sky130_fd_sc_hd__dfbbp_1
x66 D[1] comparator_out_buff resetb net9 VSS VSS VDD VDD D[2] net18 sky130_fd_sc_hd__dfbbp_1
x69 D[0] comparator_out_buff resetb net10 VSS VSS VDD VDD D[1] net19 sky130_fd_sc_hd__dfbbp_1
x72 net2 comparator_out_buff resetb net11 VSS VSS VDD VDD D[0] net20 sky130_fd_sc_hd__dfbbp_1
x75 VSS VSS resetb net21 VSS VSS VDD VDD net2 net22 sky130_fd_sc_hd__dfbbp_1
x77 EOB VSS VSS VDD VDD net21 sky130_fd_sc_hd__inv_1
* noconn #net22
x78 check[2] check[1] check[0] net3 sel_bit[0] sel_bit[1] VSS VSS VDD VDD EOB
+ sky130_fd_sc_hd__mux4_4
* noconn #net12
C2[17] resetb VSS 5f m=1
C2[16] resetb VSS 5f m=1
C2[15] resetb VSS 5f m=1
C2[14] resetb VSS 5f m=1
C2[13] resetb VSS 5f m=1
C2[12] resetb VSS 5f m=1
C2[11] resetb VSS 5f m=1
C2[10] resetb VSS 5f m=1
C2[9] resetb VSS 5f m=1
C2[8] resetb VSS 5f m=1
C2[7] resetb VSS 5f m=1
C2[6] resetb VSS 5f m=1
C2[5] resetb VSS 5f m=1
C2[4] resetb VSS 5f m=1
C2[3] resetb VSS 5f m=1
C2[2] resetb VSS 5f m=1
C2[1] resetb VSS 5f m=1
C2[0] resetb VSS 5f m=1
C2 net1 VSS 5f m=1
C3 check[6] VSS 5f m=1
C4 check[5] VSS 5f m=1
C5 check[4] VSS 5f m=1
C6 check[3] VSS 5f m=1
C7 check[2] VSS 5f m=1
C8 check[1] VSS 5f m=1
C9 check[0] VSS 5f m=1
C10 net3 VSS 5f m=1
C11 EOB VSS 5f m=1
C12 D[6] VSS 5f m=1
C13 D[5] VSS 5f m=1
C14 D[4] VSS 5f m=1
C15 D[3] VSS 5f m=1
C16 D[2] VSS 5f m=1
C17 D[1] VSS 5f m=1
C18 D[0] VSS 5f m=1
C19 net2 VSS 5f m=1
C20 D[7] VSS 5f m=1
C21 D[6] VSS 5f m=1
C22 D[5] VSS 5f m=1
C23 D[4] VSS 5f m=1
C24 D[3] VSS 5f m=1
C25 D[2] VSS 5f m=1
C26 D[1] VSS 5f m=1
C27 D[0] VSS 5f m=1
C28 net5 VSS 5f m=1
C29 net6 VSS 5f m=1
C30 net7 VSS 5f m=1
C31 net8 VSS 5f m=1
C32 net9 VSS 5f m=1
C33 net10 VSS 5f m=1
C34 net11 VSS 5f m=1
C35 net21 VSS 5f m=1
C36 clk_sar_buff VSS 5f m=1
x1 reset VSS VSS VDD VDD net23 sky130_fd_sc_hd__buf_1
x2 clk_sar VSS VSS VDD VDD net24 sky130_fd_sc_hd__buf_1
x3 net23 VSS VSS VDD VDD net25 sky130_fd_sc_hd__buf_4
x4 net25 VSS VSS VDD VDD resetb sky130_fd_sc_hd__buf_16
* noconn #net20
* noconn #net19
* noconn #net18
* noconn #net17
* noconn #net16
* noconn #net15
* noconn #net14
* noconn #net13
x5 net24 VSS VSS VDD VDD clk_sar_buff sky130_fd_sc_hd__buf_4
x6 comparator_out VSS VSS VDD VDD net26 sky130_fd_sc_hd__buf_1
x7 net26 VSS VSS VDD VDD comparator_out_buff sky130_fd_sc_hd__buf_4
C1[17] comparator_out_buff VSS 5f m=1
C1[16] comparator_out_buff VSS 5f m=1
C1[15] comparator_out_buff VSS 5f m=1
C1[14] comparator_out_buff VSS 5f m=1
C1[13] comparator_out_buff VSS 5f m=1
C1[12] comparator_out_buff VSS 5f m=1
C1[11] comparator_out_buff VSS 5f m=1
C1[10] comparator_out_buff VSS 5f m=1
C1[9] comparator_out_buff VSS 5f m=1
C1[8] comparator_out_buff VSS 5f m=1
C1[7] comparator_out_buff VSS 5f m=1
C1[6] comparator_out_buff VSS 5f m=1
C1[5] comparator_out_buff VSS 5f m=1
C1[4] comparator_out_buff VSS 5f m=1
C1[3] comparator_out_buff VSS 5f m=1
C1[2] comparator_out_buff VSS 5f m=1
C1[1] comparator_out_buff VSS 5f m=1
C1[0] comparator_out_buff VSS 5f m=1
.ends


* expanding   symbol:  ../xschem/hgu_sarlogic_sw_ctrl.sym # of pins=10
** sym_path: hgu/xschem/hgu_sarlogic_sw_ctrl.sym
** sch_path: hgu/xschem/hgu_sarlogic_sw_ctrl.sch
.subckt hgu_sarlogic_sw_ctrl VDD VSS vdd_sw[1] vdd_sw[2] vdd_sw[3] vdd_sw[4] vdd_sw[5] vdd_sw[6]
+ vdd_sw[7] vdd_sw_b[1] vdd_sw_b[2] vdd_sw_b[3] vdd_sw_b[4] vdd_sw_b[5] vdd_sw_b[6] vdd_sw_b[7] D[1] D[2] D[3]
+ D[4] D[5] D[6] D[7] vss_sw[1] vss_sw[2] vss_sw[3] vss_sw[4] vss_sw[5] vss_sw[6] vss_sw[7] check[0]
+ check[1] check[2] check[3] check[4] check[5] check[6] vss_sw_b[1] vss_sw_b[2] vss_sw_b[3] vss_sw_b[4]
+ vss_sw_b[5] vss_sw_b[6] vss_sw_b[7] READY reset
*.opin vdd_sw[1],vdd_sw[2],vdd_sw[3],vdd_sw[4],vdd_sw[5],vdd_sw[6],vdd_sw[7]
*.opin vdd_sw_b[1],vdd_sw_b[2],vdd_sw_b[3],vdd_sw_b[4],vdd_sw_b[5],vdd_sw_b[6],vdd_sw_b[7]
*.opin vss_sw[1],vss_sw[2],vss_sw[3],vss_sw[4],vss_sw[5],vss_sw[6],vss_sw[7]
*.opin vss_sw_b[1],vss_sw_b[2],vss_sw_b[3],vss_sw_b[4],vss_sw_b[5],vss_sw_b[6],vss_sw_b[7]
*.ipin VDD
*.ipin VSS
*.ipin READY
*.ipin D[1],D[2],D[3],D[4],D[5],D[6],D[7]
*.ipin check[0],check[1],check[2],check[3],check[4],check[5],check[6]
*.ipin reset
x4 net1 D[7] VDD resetb VSS VSS VDD VDD vdd_sw[7] vdd_sw_b[7] sky130_fd_sc_hd__dfbbn_1
x5 net2 D[7] resetb VDD VSS VSS VDD VDD vss_sw[7] vss_sw_b[7] sky130_fd_sc_hd__dfbbn_1
x19 net3 D[6] VDD resetb VSS VSS VDD VDD vdd_sw[6] vdd_sw_b[6] sky130_fd_sc_hd__dfbbn_1
x21 net4 D[6] resetb VDD VSS VSS VDD VDD vss_sw[6] vss_sw_b[6] sky130_fd_sc_hd__dfbbn_1
x23 net5 D[5] VDD resetb VSS VSS VDD VDD vdd_sw[5] vdd_sw_b[5] sky130_fd_sc_hd__dfbbn_1
x24 net6 D[5] resetb VDD VSS VSS VDD VDD vss_sw[5] vss_sw_b[5] sky130_fd_sc_hd__dfbbn_1
x25 net7 D[4] VDD resetb VSS VSS VDD VDD vdd_sw[4] vdd_sw_b[4] sky130_fd_sc_hd__dfbbn_1
x26 net8 D[4] resetb VDD VSS VSS VDD VDD vss_sw[4] vss_sw_b[4] sky130_fd_sc_hd__dfbbn_1
x28 net9 D[3] VDD resetb VSS VSS VDD VDD vdd_sw[3] vdd_sw_b[3] sky130_fd_sc_hd__dfbbn_1
x29 net10 D[3] resetb VDD VSS VSS VDD VDD vss_sw[3] vss_sw_b[3] sky130_fd_sc_hd__dfbbn_1
x31 net11 D[2] VDD resetb VSS VSS VDD VDD vdd_sw[2] vdd_sw_b[2] sky130_fd_sc_hd__dfbbn_1
x32 net12 D[2] resetb VDD VSS VSS VDD VDD vss_sw[2] vss_sw_b[2] sky130_fd_sc_hd__dfbbn_1
x34 net13 D[1] VDD resetb VSS VSS VDD VDD vdd_sw[1] vdd_sw_b[1] sky130_fd_sc_hd__dfbbn_1
x35 net14 D[1] resetb VDD VSS VSS VDD VDD vss_sw[1] vss_sw_b[1] sky130_fd_sc_hd__dfbbn_1
x6 VSS READY_buff check[6] VSS VSS VDD VDD net1 sky130_fd_sc_hd__mux2_1
x7 VSS READY_buff check[6] VSS VSS VDD VDD net2 sky130_fd_sc_hd__mux2_1
x8 VSS READY_buff check[5] VSS VSS VDD VDD net3 sky130_fd_sc_hd__mux2_1
x9 VSS READY_buff check[5] VSS VSS VDD VDD net4 sky130_fd_sc_hd__mux2_1
x10 VSS READY_buff check[4] VSS VSS VDD VDD net5 sky130_fd_sc_hd__mux2_1
x11 VSS READY_buff check[4] VSS VSS VDD VDD net6 sky130_fd_sc_hd__mux2_1
x12 VSS READY_buff check[3] VSS VSS VDD VDD net7 sky130_fd_sc_hd__mux2_1
x13 VSS READY_buff check[3] VSS VSS VDD VDD net8 sky130_fd_sc_hd__mux2_1
x14 VSS READY_buff check[2] VSS VSS VDD VDD net9 sky130_fd_sc_hd__mux2_1
x15 VSS READY_buff check[2] VSS VSS VDD VDD net10 sky130_fd_sc_hd__mux2_1
x16 VSS READY_buff check[1] VSS VSS VDD VDD net11 sky130_fd_sc_hd__mux2_1
x17 VSS READY_buff check[1] VSS VSS VDD VDD net12 sky130_fd_sc_hd__mux2_1
x18 VSS READY_buff check[0] VSS VSS VDD VDD net13 sky130_fd_sc_hd__mux2_1
x20 VSS READY_buff check[0] VSS VSS VDD VDD net14 sky130_fd_sc_hd__mux2_1
C2[17] resetb VSS 5f m=1
C2[16] resetb VSS 5f m=1
C2[15] resetb VSS 5f m=1
C2[14] resetb VSS 5f m=1
C2[13] resetb VSS 5f m=1
C2[12] resetb VSS 5f m=1
C2[11] resetb VSS 5f m=1
C2[10] resetb VSS 5f m=1
C2[9] resetb VSS 5f m=1
C2[8] resetb VSS 5f m=1
C2[7] resetb VSS 5f m=1
C2[6] resetb VSS 5f m=1
C2[5] resetb VSS 5f m=1
C2[4] resetb VSS 5f m=1
C2[3] resetb VSS 5f m=1
C2[2] resetb VSS 5f m=1
C2[1] resetb VSS 5f m=1
C2[0] resetb VSS 5f m=1
x1 reset VSS VSS VDD VDD net15 sky130_fd_sc_hd__buf_1
x3 net15 VSS VSS VDD VDD net16 sky130_fd_sc_hd__buf_4
x2 net16 VSS VSS VDD VDD resetb sky130_fd_sc_hd__buf_16
x22 READY VSS VSS VDD VDD net17 sky130_fd_sc_hd__buf_1
x27 net17 VSS VSS VDD VDD net18 sky130_fd_sc_hd__buf_4
x30 net18 VSS VSS VDD VDD READY_buff sky130_fd_sc_hd__buf_16
**** begin user architecture code



.lib /foss/pdks/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.include /foss/designs/hgu_goss/hgu/mag/hgu_cdac_unit.spice



**** end user architecture code
.ends


* expanding   symbol:  ../xschem/hgu_delay_no_code.sym # of pins=5
** sym_path: hgu/xschem/hgu_delay_no_code.sym
** sch_path: hgu/xschem/hgu_delay_no_code.sch
.subckt hgu_delay_no_code VDD IN OUT VSS code[0] code[1] code[2] code[3]
*.ipin IN
*.ipin VDD
*.ipin VSS
*.opin OUT
*.ipin code[0],code[1],code[2],code[3]
XM13 OUT Uc net2 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM15 net2 Uc VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.8 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 VDD OUT net2 VSS sky130_fd_pr__nfet_01v8 L=0.15 W='0.42 * 2 ' nf=2 ad='int((nf+1)/2) * W / nf * 0.29'
+ as='int((nf+2)/2) * W / nf * 0.29' pd='2*int((nf+1)/2) * (W / nf + 0.29)' ps='2*int((nf+2)/2) * (W / nf + 0.29)'
+ nrd='0.29 / W ' nrs='0.29 / W ' sa=0 sb=0 sd=0 mult=1 m=1
XM3 VDD Uc VDD VDD sky130_fd_pr__pfet_01v8 L=6 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM46 OUT Uc net1 VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM47 net1 Uc VDD VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM48 VSS OUT net1 VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W='0.42 * 2 ' nf=2 ad='int((nf+1)/2) * W / nf * 0.29'
+ as='int((nf+2)/2) * W / nf * 0.29' pd='2*int((nf+1)/2) * (W / nf + 0.29)' ps='2*int((nf+2)/2) * (W / nf + 0.29)'
+ nrd='0.29 / W ' nrs='0.29 / W ' sa=0 sb=0 sd=0 mult=1 m=1
x2 code[0] VSS Uc hgu_sw_cap DELAY_CAP=5f
x3[1] code[1] VSS Uc hgu_sw_cap DELAY_CAP=5f
x3[0] code[1] VSS Uc hgu_sw_cap DELAY_CAP=5f
x4[3] code[2] VSS Uc hgu_sw_cap DELAY_CAP=5f
x4[2] code[2] VSS Uc hgu_sw_cap DELAY_CAP=5f
x4[1] code[2] VSS Uc hgu_sw_cap DELAY_CAP=5f
x4[0] code[2] VSS Uc hgu_sw_cap DELAY_CAP=5f
x5[7] code[3] Uc VDD VSS hgu_sw_cap_pmos
x5[6] code[3] Uc VDD VSS hgu_sw_cap_pmos
x5[5] code[3] Uc VDD VSS hgu_sw_cap_pmos
x5[4] code[3] Uc VDD VSS hgu_sw_cap_pmos
x5[3] code[3] Uc VDD VSS hgu_sw_cap_pmos
x5[2] code[3] Uc VDD VSS hgu_sw_cap_pmos
x5[1] code[3] Uc VDD VSS hgu_sw_cap_pmos
x5[0] code[3] Uc VDD VSS hgu_sw_cap_pmos
x3 VDD IN Uc hgu_pfet_hvt_stack_in_delay
x4 IN Uc VSS hgu_nfet_hvt_stack_in_delay
.ends


* expanding   symbol:  ../xschem/hgu_clk_div.sym # of pins=4
** sym_path: hgu/xschem/hgu_clk_div.sym
** sch_path: hgu/xschem/hgu_clk_div.sch
.subckt hgu_clk_div DIV_CLK CLK RESET SET
*.opin DIV_CLK
*.ipin SET
*.ipin RESET
*.ipin CLK
x2 CLK D_loop net1 net2 VGND VNB VPB VPWR DIV_CLK D_loop sky130_fd_sc_hd__dfbbp_1
x3 SET VGND VNB VPB VPWR net2 sky130_fd_sc_hd__inv_1
x4 RESET VGND VNB VPB VPWR net1 sky130_fd_sc_hd__inv_1
.ends


* expanding   symbol:  ../xschem/hgu_delay.sym # of pins=8
** sym_path: hgu/xschem/hgu_delay.sym
** sch_path: hgu/xschem/hgu_delay.sch
.subckt hgu_delay OUT IN VDD VSS CAP_CTRL_CODE0[0] CAP_CTRL_CODE0[1] CAP_CTRL_CODE0[2]
+ CAP_CTRL_CODE0[3] CAP_CTRL_CODE1[0] CAP_CTRL_CODE1[1] CAP_CTRL_CODE1[2] CAP_CTRL_CODE1[3] CAP_CTRL_CODE2[0]
+ CAP_CTRL_CODE2[1] CAP_CTRL_CODE2[2] CAP_CTRL_CODE2[3] CAP_CTRL_CODE3[0] CAP_CTRL_CODE3[1] CAP_CTRL_CODE3[2]
+ CAP_CTRL_CODE3[3]  DELAY_CAP=DELAY_CAP
*.ipin IN
*.ipin VDD
*.ipin VSS
*.opin OUT
*.ipin CAP_CTRL_CODE1[0],CAP_CTRL_CODE1[1],CAP_CTRL_CODE1[2],CAP_CTRL_CODE1[3]
*.ipin CAP_CTRL_CODE2[0],CAP_CTRL_CODE2[1],CAP_CTRL_CODE2[2],CAP_CTRL_CODE2[3]
*.ipin CAP_CTRL_CODE3[0],CAP_CTRL_CODE3[1],CAP_CTRL_CODE3[2],CAP_CTRL_CODE3[3]
*.ipin CAP_CTRL_CODE0[0],CAP_CTRL_CODE0[1],CAP_CTRL_CODE0[2],CAP_CTRL_CODE0[3]
x4 VDD IN net1 VSS CAP_CTRL_CODE0[0] CAP_CTRL_CODE0[1] CAP_CTRL_CODE0[2] CAP_CTRL_CODE0[3]
+ hgu_delay_no_code
x1 VDD net1 net2 VSS CAP_CTRL_CODE1[0] CAP_CTRL_CODE1[1] CAP_CTRL_CODE1[2] CAP_CTRL_CODE1[3]
+ hgu_delay_no_code
x2 VDD net2 net3 VSS CAP_CTRL_CODE2[0] CAP_CTRL_CODE2[1] CAP_CTRL_CODE2[2] CAP_CTRL_CODE2[3]
+ hgu_delay_no_code
x3 VDD net3 OUT VSS CAP_CTRL_CODE3[0] CAP_CTRL_CODE3[1] CAP_CTRL_CODE3[2] CAP_CTRL_CODE3[3]
+ hgu_delay_no_code
.ends


* expanding   symbol:  /foss/designs/hgu_goss/hgu/xschem/hgu_sw_cap.sym # of pins=3
** sym_path: hgu/xschem/hgu_sw_cap.sym
** sch_path: hgu/xschem/hgu_sw_cap.sch
.subckt hgu_sw_cap SW VSS DELAY_SIGNAL  DELAY_CAP=DELAY_CAP
*.ipin SW
*.ipin VSS
*.iopin DELAY_SIGNAL
XM14 DELAY_SIGNAL SW net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
C1 net1 VSS 4.37f m=1
.ends


* expanding   symbol:  /foss/designs/hgu_goss/hgu/xschem/hgu_sw_cap_pmos.sym # of pins=4
** sym_path: hgu/xschem/hgu_sw_cap_pmos.sym
** sch_path: hgu/xschem/hgu_sw_cap_pmos.sch
.subckt hgu_sw_cap_pmos SW DELAY_SIGNAL VDD VSS
*.ipin SW
*.ipin VDD
*.iopin DELAY_SIGNAL
*.ipin VSS
XM16 net1 SW VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
?1 net1 DELAY_SIGNAL VSS x1
.ends


* expanding   symbol:
*+  /foss/designs/hgu_goss/hgu/xschem/../../../hgu_goss/hgu/xschem/hgu_pfet_hvt_stack_in_delay.sym # of pins=3
** sym_path: hgu/xschem/hgu_pfet_hvt_stack_in_delay.sym
** sch_path: hgu/xschem/hgu_pfet_hvt_stack_in_delay.sch
.subckt hgu_pfet_hvt_stack_in_delay VDD input_stack output_stack
*.ipin VDD
*.ipin input_stack
*.iopin output_stack
XM49 output_stack input_stack net1 VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM41 net1 input_stack net2 VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM51 net2 input_stack VDD VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:
*+  /foss/designs/hgu_goss/hgu/xschem/../../../hgu_goss/hgu/xschem/hgu_nfet_hvt_stack_in_delay.sym # of pins=3
** sym_path: hgu/xschem/hgu_nfet_hvt_stack_in_delay.sym
** sch_path: hgu/xschem/hgu_nfet_hvt_stack_in_delay.sch
.subckt hgu_nfet_hvt_stack_in_delay input_stack output_stack VSS
*.ipin VSS
*.ipin input_stack
*.iopin output_stack
XM6 output_stack input_stack net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM1 net1 input_stack net2 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 net2 input_stack net3 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 net3 input_stack net4 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 net4 input_stack net5 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 net5 input_stack net6 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 net6 input_stack net7 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 net7 input_stack net8 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 net8 input_stack VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.end
