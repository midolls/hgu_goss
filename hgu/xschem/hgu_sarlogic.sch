** sch_path: hgu/xschem/hgu_sarlogic.sch
**.subckt hgu_sarlogic VDD VSS COMP_RESULT READY EXT_CLK sar_clk
*+ sar_result[0],sar_result[1],sar_result[2],sar_result[3],sar_result[4],sar_result[5],sar_result[6],sar_result[7] sample_clk sel_bit[0],sel_bit[1]
*+ sample_delay_cap_ctrl_code[0],sample_delay_cap_ctrl_code[1],sample_delay_cap_ctrl_code[2],sample_delay_cap_ctrl_code[3],sample_delay_cap_ctrl_code[4],sample_delay_cap_ctrl_code[5],sample_delay_cap_ctrl_code[6],sample_delay_cap_ctrl_code[7],sample_delay_cap_ctrl_code[8],sample_delay_cap_ctrl_code[9],sample_delay_cap_ctrl_code[10],sample_delay_cap_ctrl_code[11],sample_delay_cap_ctrl_code[12],sample_delay_cap_ctrl_code[13],sample_delay_cap_ctrl_code[14],sample_delay_cap_ctrl_code[15] sample_clk_b vdd_sw[1],vdd_sw[2],vdd_sw[3],vdd_sw[4],vdd_sw[5],vdd_sw[6],vdd_sw[7]
*+ vdd_sw_b[1],vdd_sw_b[2],vdd_sw_b[3],vdd_sw_b[4],vdd_sw_b[5],vdd_sw_b[6],vdd_sw_b[7] vss_sw[1],vss_sw[2],vss_sw[3],vss_sw[4],vss_sw[5],vss_sw[6],vss_sw[7]
*+ vss_sw_b[1],vss_sw_b[2],vss_sw_b[3],vss_sw_b[4],vss_sw_b[5],vss_sw_b[6],vss_sw_b[7]
*+ async_resetb_delay_cap_ctrl_code[0],async_resetb_delay_cap_ctrl_code[1],async_resetb_delay_cap_ctrl_code[2],async_resetb_delay_cap_ctrl_code[3]
*+ async_setb_delay_cap_ctrl_code[0],async_setb_delay_cap_ctrl_code[1],async_setb_delay_cap_ctrl_code[2],async_setb_delay_cap_ctrl_code[3] async_delay_offset sample_delay_offset
*+ retimer_delay_code[0],retimer_delay_code[1],retimer_delay_code[2],retimer_delay_code[3]
*.ipin VDD
*.ipin VSS
*.ipin COMP_RESULT
*.ipin READY
*.ipin EXT_CLK
*.opin sar_clk
*.opin
*+ sar_result[0],sar_result[1],sar_result[2],sar_result[3],sar_result[4],sar_result[5],sar_result[6],sar_result[7]
*.opin sample_clk
*.ipin sel_bit[0],sel_bit[1]
*.ipin
*+ sample_delay_cap_ctrl_code[0],sample_delay_cap_ctrl_code[1],sample_delay_cap_ctrl_code[2],sample_delay_cap_ctrl_code[3],sample_delay_cap_ctrl_code[4],sample_delay_cap_ctrl_code[5],sample_delay_cap_ctrl_code[6],sample_delay_cap_ctrl_code[7],sample_delay_cap_ctrl_code[8],sample_delay_cap_ctrl_code[9],sample_delay_cap_ctrl_code[10],sample_delay_cap_ctrl_code[11],sample_delay_cap_ctrl_code[12],sample_delay_cap_ctrl_code[13],sample_delay_cap_ctrl_code[14],sample_delay_cap_ctrl_code[15]
*.opin sample_clk_b
*.opin vdd_sw[1],vdd_sw[2],vdd_sw[3],vdd_sw[4],vdd_sw[5],vdd_sw[6],vdd_sw[7]
*.opin vdd_sw_b[1],vdd_sw_b[2],vdd_sw_b[3],vdd_sw_b[4],vdd_sw_b[5],vdd_sw_b[6],vdd_sw_b[7]
*.opin vss_sw[1],vss_sw[2],vss_sw[3],vss_sw[4],vss_sw[5],vss_sw[6],vss_sw[7]
*.opin vss_sw_b[1],vss_sw_b[2],vss_sw_b[3],vss_sw_b[4],vss_sw_b[5],vss_sw_b[6],vss_sw_b[7]
*.ipin
*+ async_resetb_delay_cap_ctrl_code[0],async_resetb_delay_cap_ctrl_code[1],async_resetb_delay_cap_ctrl_code[2],async_resetb_delay_cap_ctrl_code[3]
*.ipin
*+ async_setb_delay_cap_ctrl_code[0],async_setb_delay_cap_ctrl_code[1],async_setb_delay_cap_ctrl_code[2],async_setb_delay_cap_ctrl_code[3]
*.ipin async_delay_offset
*.ipin sample_delay_offset
*.ipin retimer_delay_code[0],retimer_delay_code[1],retimer_delay_code[2],retimer_delay_code[3]
x1 sar_clk VDD VSS sample_clk EOB READY async_delay_offset async_resetb_delay_cap_ctrl_code[0]
+ async_resetb_delay_cap_ctrl_code[1] async_resetb_delay_cap_ctrl_code[2] async_resetb_delay_cap_ctrl_code[3]
+ async_setb_delay_cap_ctrl_code[0] async_setb_delay_cap_ctrl_code[1] async_setb_delay_cap_ctrl_code[2]
+ async_setb_delay_cap_ctrl_code[3] hgu_clk_async
x2 sample_clk_b VDD VSS EXT_CLK VSS VSS sample_clk sample_delay_cap_ctrl_code[0]
+ sample_delay_cap_ctrl_code[1] sample_delay_cap_ctrl_code[2] sample_delay_cap_ctrl_code[3] sample_delay_cap_ctrl_code[4]
+ sample_delay_cap_ctrl_code[5] sample_delay_cap_ctrl_code[6] sample_delay_cap_ctrl_code[7] sample_delay_cap_ctrl_code[8]
+ sample_delay_cap_ctrl_code[9] sample_delay_cap_ctrl_code[10] sample_delay_cap_ctrl_code[11] sample_delay_cap_ctrl_code[12]
+ sample_delay_cap_ctrl_code[13] sample_delay_cap_ctrl_code[14] sample_delay_cap_ctrl_code[15] sample_delay_offset hgu_clk_sample
x3 sel_bit[0] sel_bit[1] EOB sar_clk sar_result_temp[0] sar_result_temp[1] sar_result_temp[2]
+ sar_result_temp[3] sar_result_temp[4] sar_result_temp[5] sar_result_temp[6] sar_result_temp[7] COMP_RESULT check[0]
+ check[1] check[2] check[3] check[4] check[5] check[6] sample_clk_b VDD VSS hgu_sarlogic_8bit_logic_RC
C1 sample_clk VSS 5f m=1
C2 sar_clk VSS 5f m=1
C3 EOB VSS 5f m=1
x4 VDD VSS vdd_sw[1] vdd_sw[2] vdd_sw[3] vdd_sw[4] vdd_sw[5] vdd_sw[6] vdd_sw[7] vdd_sw_b[1]
+ vdd_sw_b[2] vdd_sw_b[3] vdd_sw_b[4] vdd_sw_b[5] vdd_sw_b[6] vdd_sw_b[7] sar_result_temp[1] sar_result_temp[2]
+ sar_result_temp[3] sar_result_temp[4] sar_result_temp[5] sar_result_temp[6] sar_result_temp[7] vss_sw[1] vss_sw[2]
+ vss_sw[3] vss_sw[4] vss_sw[5] vss_sw[6] vss_sw[7] check[0] check[1] check[2] check[3] check[4] check[5]
+ check[6] vss_sw_b[1] vss_sw_b[2] vss_sw_b[3] vss_sw_b[4] vss_sw_b[5] vss_sw_b[6] vss_sw_b[7] sar_clk
+ sample_clk_b hgu_sarlogic_sw_ctrl
x5 VDD VSS sar_result_temp[0] sar_result_temp[1] sar_result_temp[2] sar_result_temp[3]
+ sar_result_temp[4] sar_result_temp[5] sar_result_temp[6] sar_result_temp[7] EOB retimer_delay_code[0]
+ retimer_delay_code[1] retimer_delay_code[2] retimer_delay_code[3] VDD sar_result[0] sar_result[1] sar_result[2]
+ sar_result[3] sar_result[4] sar_result[5] sar_result[6] sar_result[7] hgu_sarlogic_retimer
**.ends
.end
