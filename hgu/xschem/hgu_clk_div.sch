v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -50 0 0 {name=l1 author="Stefan Schippers"}
C {sky130_stdcells/dfbbp_1.sym} 620 -230 0 0 {name=x2 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 490 -200 0 0 {name=x3 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 490 -220 0 0 {name=x4 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/opin.sym} 710 -260 0 0 {name=p1 lab=DIV_CLK}
C {devices/ipin.sym} 450 -200 0 0 {name=p2 lab=SET}
C {devices/ipin.sym} 450 -220 0 0 {name=p3 lab=RESET}
C {devices/ipin.sym} 530 -260 0 0 {name=p4 lab=CLK}
C {devices/lab_pin.sym} 530 -240 0 0 {name=p47 sig_type=std_logic lab=D_loop}
C {devices/lab_pin.sym} 710 -240 2 0 {name=p5 sig_type=std_logic lab=D_loop}
