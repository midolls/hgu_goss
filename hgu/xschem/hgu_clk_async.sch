** sch_path: hgu/xschem/hgu_clk_async.sch
**.subckt hgu_clk_async VDD ASYNC_CLK_SAR VSS sample_clk EOB READY
*+ async_resetb_delay_ctrl_code[0],async_resetb_delay_ctrl_code[1],async_resetb_delay_ctrl_code[2],async_resetb_delay_ctrl_code[3]
*+ async_setb_delay_ctrl_code[0],async_setb_delay_ctrl_code[1],async_setb_delay_ctrl_code[2],async_setb_delay_ctrl_code[3] delay_offset
*.ipin VDD
*.opin ASYNC_CLK_SAR
*.ipin VSS
*.ipin sample_clk
*.ipin EOB
*.ipin READY
*.ipin
*+ async_resetb_delay_ctrl_code[0],async_resetb_delay_ctrl_code[1],async_resetb_delay_ctrl_code[2],async_resetb_delay_ctrl_code[3]
*.ipin
*+ async_setb_delay_ctrl_code[0],async_setb_delay_ctrl_code[1],async_setb_delay_ctrl_code[2],async_setb_delay_ctrl_code[3]
*.ipin delay_offset
x3 net2 VSS sample_clk VSS VSS vDD VDD net4 sky130_fd_sc_hd__mux2_1
x8 net4 VSS EOB VSS VSS vDD VDD ASYNC_CLK_SAR sky130_fd_sc_hd__mux2_1
x27 sample_clk VDD net5 net6 VSS VSS vDD VDD net2 net7 sky130_fd_sc_hd__dfbbp_1
x9 net1 VSS VSS vDD VDD net6 sky130_fd_sc_hd__inv_1
x10 net3 VSS VSS vDD VDD net5 sky130_fd_sc_hd__inv_1
* noconn #net7
C3 net2 VSS 5f m=1
C4 net4 VSS 5f m=1
x2 VDD READY net1 VSS async_setb_delay_ctrl_code[0] async_setb_delay_ctrl_code[1]
+ async_setb_delay_ctrl_code[2] async_setb_delay_ctrl_code[3] delay_offset hgu_delay_no_code
x4 VDD ASYNC_CLK_SAR net3 VSS async_resetb_delay_ctrl_code[0] async_resetb_delay_ctrl_code[1]
+ async_resetb_delay_ctrl_code[2] async_resetb_delay_ctrl_code[3] delay_offset hgu_delay_no_code
C1 net3 VSS 5f m=1
C2 net1 VSS 5f m=1
**** begin user architecture code



.lib /foss/pdks/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.include /foss/designs/hgu_goss/hgu/mag/hgu_cdac_unit.spice
.include /foss/designs/hgu_goss/hgu/spice/hgu_comp_flat_RC.spice
.include /foss/designs/hgu_goss/hgu/spice/hgu_sarlogic_8bit_logic_flat_RC.spice



**** end user architecture code
**.ends
.end
