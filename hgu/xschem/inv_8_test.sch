v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/hgu_goss/hgu/mag/../xschem/hgu_inverter.sym} 60 10 0 0 {name=x1[0:7]}
