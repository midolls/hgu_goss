** sch_path: hgu/xschem/hgu_sw_cap_pmos.sch
**.subckt hgu_sw_cap_pmos SW VDD DELAY_SIGNAL VSS
*.ipin SW
*.ipin VDD
*.iopin DELAY_SIGNAL
*.ipin VSS
XM16 net1 SW VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
?1 net1 DELAY_SIGNAL VSS x1
**.ends
.end
