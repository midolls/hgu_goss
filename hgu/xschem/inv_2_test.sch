v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/hgu_goss/hgu/xschem/hgu_inverter.sym} 10 -20 0 0 {name=x1}
C {/foss/designs/hgu_goss/hgu/xschem/hgu_inverter.sym} 150 -20 0 0 {name=x2}
