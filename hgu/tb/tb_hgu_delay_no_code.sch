** sch_path: hgu/tb/tb_hgu_delay_no_code.sch
**.subckt tb_hgu_delay_no_code
V1 VDD GND 1.8
V12 EXT_CLK GND PULSE(0 1.8 1n 5p 5p 40n 80n)
x1 layout_vdd EXT_CLK Vout layout_vss net1[3] net1[2] net1[1] net1[0] net3 hgu_delay_no_code_RC
V3 net5 GND 1.8
V9 async_resetb_delay_cap_ctrl_code[3] GND 0
V10 async_resetb_delay_cap_ctrl_code[2] GND 0
V11 async_resetb_delay_cap_ctrl_code[1] GND 0
V4 net6 GND 1.8
V13 net7 GND 1.8
V14 net8 GND 1.8
V19 async_resetb_delay_cap_ctrl_code[0] GND 0
* noconn #net5
* noconn #net6
* noconn #net7
* noconn #net8
x2 Vout_20n EXT_CLK VDD GND net9[3] net9[2] net9[1] net9[0] net10[3] net10[2] net10[1] net10[0]
+ net11[3] net11[2] net11[1] net11[0] net12[3] net12[2] net12[1] net12[0] VDD hgu_delay DELAY_CAP=8f
x7 Vout_20n VGND VNB VPB VPWR net13 sky130_fd_sc_hd__inv_1
C3 net13 GND 10f m=1
x9 Vout VGND VNB VPB VPWR net14 sky130_fd_sc_hd__inv_1
C4 net14 GND 10f m=1
V54 VPWR GND 1.8
V55 VNB GND 0
V56 VPB GND 1.8
V57 VGND GND 0
x4 sch_vdd EXT_CLK Vout2 sch_vss net2[3] net2[2] net2[1] net2[0] net4 hgu_delay_no_code
x5 Vout2 VGND VNB VPB VPWR net15 sky130_fd_sc_hd__inv_1
C5 net15 GND 10f m=1
x8 VDD EXT_CLK Vout3 GND GND GND GND GND VDD hgu_delay_no_code
x10 Vout3 VGND VNB VPB VPWR net16 sky130_fd_sc_hd__inv_1
C6 net16 GND 10f m=1
V5 async_resetb_delay_cap_ctrl_code2[0] GND 1.8
V6 net17 GND 0
V7 net18 GND 0
V8 net19 GND 0
V15 async_resetb_delay_cap_ctrl_code2[1] GND 1.8
V16 async_resetb_delay_cap_ctrl_code2[2] GND 1.8
V17 async_resetb_delay_cap_ctrl_code2[3] GND 1.8
V18 net20 GND 0
* noconn #net20
* noconn #net19
* noconn #net18
* noconn #net17
V1[0] net21[3] async_resetb_delay_cap_ctrl_code[0] 0
V1[1] net21[2] async_resetb_delay_cap_ctrl_code[1] 0
V1[2] net21[1] async_resetb_delay_cap_ctrl_code[2] 0
V1[3] net21[0] async_resetb_delay_cap_ctrl_code[3] 0
V2[0] VDD net22[3] 0
V2[1] VDD net22[2] 0
V2[2] VDD net22[1] 0
V2[3] VDD net22[0] 0
x3[0] net22[3] VGND VNB VPB VPWR net2[3] sky130_fd_sc_hd__buf_1
x3[1] net22[2] VGND VNB VPB VPWR net2[2] sky130_fd_sc_hd__buf_1
x3[2] net22[1] VGND VNB VPB VPWR net2[1] sky130_fd_sc_hd__buf_1
x3[3] net22[0] VGND VNB VPB VPWR net2[0] sky130_fd_sc_hd__buf_1
x1[0] net21[3] VGND VNB VPB VPWR net1[3] sky130_fd_sc_hd__buf_1
x1[1] net21[2] VGND VNB VPB VPWR net1[2] sky130_fd_sc_hd__buf_1
x1[2] net21[1] VGND VNB VPB VPWR net1[1] sky130_fd_sc_hd__buf_1
x1[3] net21[0] VGND VNB VPB VPWR net1[0] sky130_fd_sc_hd__buf_1
V2 layout_vdd GND 1.8
V20 layout_vss GND 0
V21 sch_vdd GND 1.8
V22 sch_vss GND 0
V23 net23 GND 0
x6 net23 VGND VNB VPB VPWR net3 sky130_fd_sc_hd__buf_1
V4[0] VDD net24 0
V4[1] VDD net24 0
V4[2] VDD net24 0
V4[3] VDD net24 0
x3 net24 VGND VNB VPB VPWR net4 sky130_fd_sc_hd__buf_1
**** begin user architecture code



*.tran 100ns 1024us
.tran 10p 150ns

.control
	let start_vdd = 1.8
	let stop_vdd = 1.8
	let delta_vdd = 0.36
	let vdd_act = start_vdd

	foreach temp_act 25
		option temp = $temp_act

		while vdd_act le stop_vdd

			alter V1 vdd_act
			run
			plot V(EXT_CLK) V(Vout) V(Vout2) V(Vout3)
*V(Vout_20n) "async_resetb_delay_cap_ctrl_code[0]" "async_resetb_delay_cap_ctrl_code[3]"
			let vdd_act = vdd_act + delta_vdd

			let l_vdd = vdd_act * 0.2
			let h_vdd = vdd_act * 0.8
			meas tran rising_s find time when V(Vout)=l_vdd RISE=2 TD=1000p
			meas tran rising_e find time when V(Vout)=h_vdd RISE=2 TD=1000p
			let rising_time = rising_e-rising_s
			meas tran falling_s find time when V(Vout)=h_vdd FALL=1 TD=1000p
			meas tran falling_e find time when V(Vout)=l_vdd FALL=1 TD=1000p
			let falling_time = falling_e-falling_s
			meas tran IN find time when V(EXT_CLK)=0.9 RISE=2 TD=1000p
			meas tran OUT find time when V(Vout)=0.9 RISE=2 TD=1000p
			let delay_r = OUT-IN
			meas tran IN find time when V(EXT_CLK)=0.9 FALL=1 TD=1000p
			meas tran OUT find time when V(Vout)=0.9 FALL=1 TD=1000p
			let delay_f = OUT-IN

			print rising_time falling_time delay_r	delay_f
		end
		let vdd_act = start_vdd
	end

	*run
	*plot V(EXT_CLK) V(Vout)+2

.endc
.save all






.lib /foss/pdks/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.include /foss/designs/hgu_goss/hgu/mag/hgu_cdac_unit.spice
.include /foss/designs/hgu_goss/hgu/spice/hgu_delay_no_code_flat.spice
*.include /foss/designs/hgu_goss/hgu/spice/hgu_delay_no_code_flat_no_cap.spice



**** end user architecture code
**.ends

* expanding   symbol:  ../xschem/hgu_delay.sym # of pins=9
** sym_path: hgu/xschem/hgu_delay.sym
** sch_path: hgu/xschem/hgu_delay.sch
.subckt hgu_delay OUT IN VDD VSS SAMPLE_CODE0[0] SAMPLE_CODE0[1] SAMPLE_CODE0[2] SAMPLE_CODE0[3]
+ SAMPLE_CODE1[0] SAMPLE_CODE1[1] SAMPLE_CODE1[2] SAMPLE_CODE1[3] SAMPLE_CODE2[0] SAMPLE_CODE2[1] SAMPLE_CODE2[2]
+ SAMPLE_CODE2[3] SAMPLE_CODE3[0] SAMPLE_CODE3[1] SAMPLE_CODE3[2] SAMPLE_CODE3[3] sample_delay_offset
+  DELAY_CAP=DELAY_CAP
*.ipin IN
*.ipin VDD
*.ipin VSS
*.opin OUT
*.ipin SAMPLE_CODE1[0],SAMPLE_CODE1[1],SAMPLE_CODE1[2],SAMPLE_CODE1[3]
*.ipin SAMPLE_CODE2[0],SAMPLE_CODE2[1],SAMPLE_CODE2[2],SAMPLE_CODE2[3]
*.ipin SAMPLE_CODE3[0],SAMPLE_CODE3[1],SAMPLE_CODE3[2],SAMPLE_CODE3[3]
*.ipin SAMPLE_CODE0[0],SAMPLE_CODE0[1],SAMPLE_CODE0[2],SAMPLE_CODE0[3]
*.ipin sample_delay_offset
x4 VDD IN net1 VSS SAMPLE_CODE0[0] SAMPLE_CODE0[1] SAMPLE_CODE0[2] SAMPLE_CODE0[3]
+ sample_delay_offset hgu_delay_no_code
x1 VDD net1 net2 VSS SAMPLE_CODE1[0] SAMPLE_CODE1[1] SAMPLE_CODE1[2] SAMPLE_CODE1[3]
+ sample_delay_offset hgu_delay_no_code
x2 VDD net2 net3 VSS SAMPLE_CODE2[0] SAMPLE_CODE2[1] SAMPLE_CODE2[2] SAMPLE_CODE2[3]
+ sample_delay_offset hgu_delay_no_code
x3 VDD net3 OUT VSS SAMPLE_CODE3[0] SAMPLE_CODE3[1] SAMPLE_CODE3[2] SAMPLE_CODE3[3]
+ sample_delay_offset hgu_delay_no_code
.ends


* expanding   symbol:  ../xschem/hgu_delay_no_code.sym # of pins=6
** sym_path: hgu/xschem/hgu_delay_no_code.sym
** sch_path: hgu/xschem/hgu_delay_no_code.sch
.subckt hgu_delay_no_code VDD IN OUT VSS code[0] code[1] code[2] code[3] code_offset
*.ipin IN
*.ipin VDD
*.ipin VSS
*.opin OUT
*.ipin code[0],code[1],code[2],code[3]
*.ipin code_offset
XM13 OUT net1 net3 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM15 net3 net1 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM46 OUT net1 net2 VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM47 net2 net1 VDD VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
x2 code[0] VSS net1 hgu_sw_cap DELAY_CAP=5f
x3[1] code[1] VSS net1 hgu_sw_cap DELAY_CAP=5f
x3[0] code[1] VSS net1 hgu_sw_cap DELAY_CAP=5f
x4[3] code[2] VSS net1 hgu_sw_cap DELAY_CAP=5f
x4[2] code[2] VSS net1 hgu_sw_cap DELAY_CAP=5f
x4[1] code[2] VSS net1 hgu_sw_cap DELAY_CAP=5f
x4[0] code[2] VSS net1 hgu_sw_cap DELAY_CAP=5f
x5[7] net4 net1 VDD hgu_sw_cap_pmos
x5[6] net4 net1 VDD hgu_sw_cap_pmos
x5[5] net4 net1 VDD hgu_sw_cap_pmos
x5[4] net4 net1 VDD hgu_sw_cap_pmos
x5[3] net4 net1 VDD hgu_sw_cap_pmos
x5[2] net4 net1 VDD hgu_sw_cap_pmos
x5[1] net4 net1 VDD hgu_sw_cap_pmos
x5[0] net4 net1 VDD hgu_sw_cap_pmos
x10 code[3] VSS VSS VDD VDD net4 sky130_fd_sc_hd__inv_1
x7 code_offset VSS net1 hgu_sw_cap DELAY_CAP=5f
x6 net5 net1 VDD hgu_sw_cap_pmos
x11 code_offset VSS VSS VDD VDD net5 sky130_fd_sc_hd__inv_1
x8 VDD IN net1 hgu_pfet_hvt_stack_in_delay
x9 IN net1 VSS hgu_nfet_hvt_stack_in_delay
XM48 VSS OUT net2 VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.84 nf=2 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM1 VDD OUT net3 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.84 nf=2 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  /foss/designs/hgu_goss/hgu/xschem/hgu_sw_cap.sym # of pins=3
** sym_path: hgu/xschem/hgu_sw_cap.sym
** sch_path: hgu/xschem/hgu_sw_cap.sch
.subckt hgu_sw_cap SW VSS DELAY_SIGNAL  DELAY_CAP=DELAY_CAP
*.ipin SW
*.ipin VSS
*.iopin DELAY_SIGNAL
XM14 DELAY_SIGNAL SW net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
C1 net1 VSS 4.37f m=1
.ends


* expanding   symbol:  /foss/designs/hgu_goss/hgu/xschem/hgu_sw_cap_pmos.sym # of pins=3
** sym_path: hgu/xschem/hgu_sw_cap_pmos.sym
** sch_path: hgu/xschem/hgu_sw_cap_pmos.sch
.subckt hgu_sw_cap_pmos SW DELAY_SIGNAL VDD
*.ipin SW
*.ipin VDD
*.iopin DELAY_SIGNAL
XM16 net1 SW DELAY_SIGNAL VDD sky130_fd_pr__pfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
?1 VDD net1 VDD x1
.ends


* expanding   symbol:
*+  /foss/designs/hgu_goss/hgu/xschem/../../../hgu_goss/hgu/xschem/hgu_pfet_hvt_stack_in_delay.sym # of pins=3
** sym_path: hgu/xschem/hgu_pfet_hvt_stack_in_delay.sym
** sch_path: hgu/xschem/hgu_pfet_hvt_stack_in_delay.sch
.subckt hgu_pfet_hvt_stack_in_delay VDD input_stack output_stack
*.ipin VDD
*.ipin input_stack
*.iopin output_stack
XM1 output_stack input_stack net1 VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 net1 input_stack net2 VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 net2 input_stack VDD VDD sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:
*+  /foss/designs/hgu_goss/hgu/xschem/../../../hgu_goss/hgu/xschem/hgu_nfet_hvt_stack_in_delay.sym # of pins=3
** sym_path: hgu/xschem/hgu_nfet_hvt_stack_in_delay.sym
** sch_path: hgu/xschem/hgu_nfet_hvt_stack_in_delay.sch
.subckt hgu_nfet_hvt_stack_in_delay input_stack output_stack VSS
*.ipin VSS
*.ipin input_stack
*.iopin output_stack
XM6 output_stack input_stack net1 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM1 net1 input_stack net2 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 net2 input_stack net3 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 net3 input_stack net4 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 net4 input_stack net5 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 net5 input_stack net6 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.43 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM7 net6 input_stack net7 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM8 net7 input_stack net8 VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM9 net8 input_stack VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL VDD
.GLOBAL GND
.GLOBAL async_resetb_delay_cap_ctrl_code[3]
.GLOBAL async_resetb_delay_cap_ctrl_code[2]
.GLOBAL async_resetb_delay_cap_ctrl_code[1]
.GLOBAL async_resetb_delay_cap_ctrl_code[0]
.GLOBAL VGND
.GLOBAL VNB
.GLOBAL VPB
.GLOBAL VPWR
.GLOBAL async_resetb_delay_cap_ctrl_code2[3]
.GLOBAL async_resetb_delay_cap_ctrl_code2[2]
.GLOBAL async_resetb_delay_cap_ctrl_code2[1]
.GLOBAL async_resetb_delay_cap_ctrl_code2[0]
.end
