** sch_path: hgu/tb/tb_hgu_cdac_unit.sch
**.subckt tb_hgu_cdac_unit
V2 net1 GND PULSE(0 1.8 0 5p 5p 50n 100n)
R1 a net1 1k m=1
V1 vdd GND 1.8
?1 a GND GND hgu_cdac_unit_flat
**** begin user architecture code


.save all
.temp = 100
.tran 100p 400n
.OPTIONS savecurrent
.include /foss/designs/hgu_goss/hgu/mag/hgu_cdac_unit_flat.spice

.control
	run
        plot v(a)

.endc


.lib $::SKYWATER_MODELS/sky130.lib.spice tt
**** end user architecture code
**.ends
.GLOBAL GND
.end
