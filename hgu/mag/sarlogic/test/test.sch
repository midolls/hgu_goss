v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sky130_stdcells/inv_1.sym} 30 0 0 0 {name=x1 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} -10 0 0 0 {name=p1 sig_type=std_logic lab=in}
C {devices/lab_pin.sym} 150 0 2 0 {name=p2 sig_type=std_logic lab=out}
C {devices/ipin.sym} 20 -60 0 0 {name=p3 lab=in}
C {devices/opin.sym} 120 -60 0 0 {name=p4 lab=out}
C {sky130_stdcells/inv_1.sym} 110 0 0 0 {name=x2 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {devices/ipin.sym} 20 -40 0 0 {name=p5 lab=VDD}
C {devices/ipin.sym} 20 -30 0 0 {name=p6 lab=VSS}
