v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -40 -30 0 0 {name=p1 lab=en}
C {devices/ipin.sym} -40 -10 0 0 {name=p2 lab=vdd}
C {devices/ipin.sym} -40 10 0 0 {name=p3 lab=gnd}
C {devices/opin.sym} 20 -30 0 0 {name=p4 lab=ring_osil}
