** sch_path: tb/tb_hgu_delay_no_code.sch
**.subckt tb_hgu_delay_no_code
V1 VDD GND 1.8
V12 EXT_CLK GND PULSE(0 1.8 1n 500p 500p 40n 80n)
x1 layout_vdd EXT_CLK Vout layout_vss async_resetb_delay_cap_ctrl_code[0]
+ async_resetb_delay_cap_ctrl_code[1] async_resetb_delay_cap_ctrl_code[2] async_resetb_delay_cap_ctrl_code[3] GND hgu_delay_no_code_RC
V3 net3 GND 1.8
V9 async_resetb_delay_cap_ctrl_code[3] GND 0
V10 async_resetb_delay_cap_ctrl_code[2] GND 0
V11 async_resetb_delay_cap_ctrl_code[1] GND 0
V4 net4 GND 1.8
V13 net5 GND 1.8
V14 net6 GND 1.8
V19 async_resetb_delay_cap_ctrl_code[0] GND 0
* noconn #net3
* noconn #net4
* noconn #net5
* noconn #net6
x2 Vout_20n EXT_CLK VDD GND net7[3] net7[2] net7[1] net7[0] net8[3] net8[2] net8[1] net8[0] net9[3]
+ net9[2] net9[1] net9[0] net10[3] net10[2] net10[1] net10[0] VDD hgu_delay
x7 Vout_20n VGND VNB VPB VPWR net11 sky130_fd_sc_hd__inv_1
C3 net11 GND 10f m=1
C4 Vout GND 10f m=1
V54 VPWR GND 1.8
V55 VNB GND 0
V56 VPB GND 1.8
V57 VGND GND 0
x4 sch_vdd EXT_CLK Vout2 sch_vss net1[3] net1[2] net1[1] net1[0] net2 hgu_delay_no_code
x5 Vout2 VGND VNB VPB VPWR net12 sky130_fd_sc_hd__inv_1
C5 net12 GND 10f m=1
x8 VDD EXT_CLK Vout3 GND GND GND GND GND VDD hgu_delay_no_code
x10 Vout3 VGND VNB VPB VPWR net13 sky130_fd_sc_hd__inv_1
C6 net13 GND 10f m=1
V5 async_resetb_delay_cap_ctrl_code2[0] GND 1.8
V6 net14 GND 0
V7 net15 GND 0
V8 net16 GND 0
V15 async_resetb_delay_cap_ctrl_code2[1] GND 1.8
V16 async_resetb_delay_cap_ctrl_code2[2] GND 1.8
V17 async_resetb_delay_cap_ctrl_code2[3] GND 1.8
V18 net17 GND 0
* noconn #net17
* noconn #net16
* noconn #net15
* noconn #net14
V2[0] VDD net18[3] 0
V2[1] VDD net18[2] 0
V2[2] VDD net18[1] 0
V2[3] VDD net18[0] 0
x3[0] net18[3] VGND VNB VPB VPWR net1[3] sky130_fd_sc_hd__buf_1
x3[1] net18[2] VGND VNB VPB VPWR net1[2] sky130_fd_sc_hd__buf_1
x3[2] net18[1] VGND VNB VPB VPWR net1[1] sky130_fd_sc_hd__buf_1
x3[3] net18[0] VGND VNB VPB VPWR net1[0] sky130_fd_sc_hd__buf_1
V2 layout_vdd GND 1.8
V20 layout_vss GND 0
V21 sch_vdd GND 1.8
V22 sch_vss GND 0
V4[0] VDD net19 0
V4[1] VDD net19 0
V4[2] VDD net19 0
V4[3] VDD net19 0
x3 net19 VGND VNB VPB VPWR net2 sky130_fd_sc_hd__buf_1
**** begin user architecture code



*.tran 100ns 1024us
.tran 10p 150ns

.control
	let start_vdd = 1.8
	let stop_vdd = 1.8
	let delta_vdd = 0.36
	let vdd_act = start_vdd

	foreach temp_act 25
		option temp = $temp_act

		while vdd_act le stop_vdd

			alter V1 vdd_act
			run
			plot V(EXT_CLK) V(Vout) V(Vout2) V(Vout3)
*V(Vout_20n) "async_resetb_delay_cap_ctrl_code[0]" "async_resetb_delay_cap_ctrl_code[3]"
			let vdd_act = vdd_act + delta_vdd

			let l_vdd = vdd_act * 0.2
			let h_vdd = vdd_act * 0.8
			meas tran rising_s find time when V(Vout)=l_vdd RISE=2 TD=1000p
			meas tran rising_e find time when V(Vout)=h_vdd RISE=2 TD=1000p
			let rising_time = rising_e-rising_s
			meas tran falling_s find time when V(Vout)=h_vdd FALL=1 TD=1000p
			meas tran falling_e find time when V(Vout)=l_vdd FALL=1 TD=1000p
			let falling_time = falling_e-falling_s
			meas tran IN find time when V(EXT_CLK)=0.9 RISE=2 TD=1000p
			meas tran OUT find time when V(Vout)=0.9 RISE=2 TD=1000p
			let delay_r = OUT-IN
			meas tran IN find time when V(EXT_CLK)=0.9 FALL=1 TD=1000p
			meas tran OUT find time when V(Vout)=0.9 FALL=1 TD=1000p
			let delay_f = OUT-IN

			print rising_time falling_time delay_r	delay_f
		end
		let vdd_act = start_vdd
	end

	*run
	*plot V(EXT_CLK) V(Vout)+2

.endc
.save all






.lib /foss/pdks/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /foss/pdks/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.include /foss/designs/hgu_goss/hgu/mag/hgu_cdac_unit.spice
.include /foss/designs/hgu_goss/hgu/spice/hgu_delay_no_code_flat.spice
.include /foss/designs/hgu_goss/hgu/spice/hgu_delay_flat.spice



**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
.GLOBAL async_resetb_delay_cap_ctrl_code[3]
.GLOBAL async_resetb_delay_cap_ctrl_code[2]
.GLOBAL async_resetb_delay_cap_ctrl_code[1]
.GLOBAL async_resetb_delay_cap_ctrl_code[0]
.GLOBAL VGND
.GLOBAL VNB
.GLOBAL VPB
.GLOBAL VPWR
.GLOBAL async_resetb_delay_cap_ctrl_code2[3]
.GLOBAL async_resetb_delay_cap_ctrl_code2[2]
.GLOBAL async_resetb_delay_cap_ctrl_code2[1]
.GLOBAL async_resetb_delay_cap_ctrl_code2[0]
.end
